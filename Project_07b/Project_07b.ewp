# IAR project Project_07b.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR2355 MSP430FR2355
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ./
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr2355.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: ADC.c black_line.c clocks.c display.c init.c interrupt_ADC.c interrupt_ports.c interrupt_serial.c interrupt_timers.c IOT.c led.c main.c menus.c ports.c Serial.c switches.c system.c test.c timers.c wheels.c
  group Compiled
    Compiled/: LCD.r43
